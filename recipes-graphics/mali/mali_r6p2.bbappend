MALI_EGL_TYPE = "fbdev"

